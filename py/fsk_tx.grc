options:
  parameters:
    author: sdr
    generate_options: no_gui
    id: fsk_tx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: PAGER_ID
  id: variable
  parameters:
    value: '0x0B'
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: transmit_freq - freq_offset
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: freq_offset
  id: variable
  parameters:
    value: samp_rate/4
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '5'
    stop: '75'
    value: '50'
  states: {state: disabled}
- name: rf_gain
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1600'
  states: {}
- name: transmit_freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: 467.75e6
  states: {state: disabled}
- name: transmit_freq
  id: variable
  parameters:
    value: 467.75e6
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: (2 * 3.14 * deviation)/samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pdu_gen.tx_pdu
    period: '5000'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '2'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '1600'
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: pdu_gen
  id: epy_module
  parameters:
    source_code: "# this module will be imported in the into your flowgraph\nimport pmt\n\nPAGER_ID = 0x0B\n\n# payload\npayload = [\n    0xAA, 0xAA, 0xAA,  # preamble\n    0xFC, 0x2D,        # sync word\n    0x02,              # site id\n    0x08,              # system id\n    PAGER_ID,          # pager id\n    0x00, 0x00, 0x00, 0x00, 0x00, # reserved fields\n    0x01,              # action\n    0x00               # checksum\n        ]\n\n\n# this is inverted manchester\ndef manchester_encode(payload):\n    encoded = []\n    for b in payload:\n        e = 0x55\n        if b & 0x80:  \n            e ^= 0xC0\n        if b & 0x40:  \n            e ^= 0x30\n        if b & 0x20:  \n            e ^= 0x0C\n        if b & 0x10:  \n            e ^= 0x03\n        encoded.append(e)\n        e = 0x55\n        if b & 0x08:  \n            e ^= 0xC0\n        if b & 0x04:  \n            e ^= 0x30\n        if b & 0x02:  \n            e ^= 0x0C\n        if b & 0x01:  \n            e ^= 0x03\n        encoded.append(e)\n    return encoded\n\n\n# set checksum\nacs = 1 + sum(payload[:-1]) % 256\nacs = 0x40\npayload[-1] = acs\nprint(\"cs={:02X}\".format(payload[-1]))\n\n# manchester encode \nencoded_bytes = manchester_encode(payload)\n\n# build the burst\nburst = [0x00, ] + 3 * encoded_bytes + [0x00, ]\nvec_len = len(burst)\n\n# create empty vector pmt\nvec = pmt.make_u8vector(vec_len, 0x00)\n\nif True:\n    for b in burst:\n        print(\"{:02X}\".format(b), end=' ')\n    print()\n\n# fill it with the intended bytes\nfor i in range(vec_len):\n    pmt.u8vector_set(vec, i, burst[i])\n\ntx_pdu = pmt.cons(pmt.PMT_NIL, vec)\n\n\n"
  states: {state: disabled}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    gain0: rf_gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: tcp://127.0.0.1:5555
    timeout: '100'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_message_strobe_0, strobe, pdu_pdu_to_tagged_stream_0, pdus]
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_repeat_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_multiply_const_vxx_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [zeromq_pull_msg_source_0, out, pdu_pdu_to_tagged_stream_0, pdus]

metadata:
  file_format: 1
  grc_version: 3.10.7.0
